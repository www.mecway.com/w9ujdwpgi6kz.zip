** Generated by Mecway 19.0
*NODE
1,-0.004148532527061,0.01265740753492,-0.023
2,0.006469130038102,0.01162216062823,-0.023
3,0.004714953627729,0.01260036538566,-0.023
4,0.007711246556956,0.01099430791221,-0.023
5,0.006985617562502,0.01140181140061,-0.023
6,0.01220377097608,0.005691990883925,-0.023
7,0.01272715722995,-0.003128628188894,-0.023
8,0.01338277838385,-0.0006512282636041,-0.023
9,0.01334110344039,0.000102664976736,-0.023
10,-0.007776773610882,-0.01093063236944,-0.023
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*ELEMENT,TYPE=C3D10
1,77893,77850,77910,77849,98517,98518,93103,97964,94699,98519
2,78255,78254,78283,78284,96945,98520,93831,93832,97275,93835
3,77132,78232,78256,77171,97597,98521,92691,79533,94017,92690
4,77599,78192,77201,77547,96761,93985,96577,92143,93987,93988
5,77032,78101,78082,78084,97083,97082,94597,98523,98522,98524
6,77374,78445,77458,77344,97794,96541,91607,91513,97354,1384
7,78155,78175,78157,78156,94013,94014,94012,96483,94530,95912
8,76664,78278,78258,76926,97207,97208,97210,78782,98513,98516
9,77520,76851,77469,77519,91902,91671,98525,91904,91900,98508
10,78071,78043,76915,77030,98095,98045,98526,98527,97827,79103
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*ELSET,ELSET=Washer_2
17526
17527
17528
17529
17530
17531
17532
17533
17534
17535
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*ELSET,ELSET=Bolt
59074
59075
59076
59077
59078
59079
59080
59081
59082
59083
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*ELSET,ELSET=Material_1
1
2
3
4
5
6
7
8
9
10
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*ELSET,ELSET=Material_2
43069
43070
43071
43072
43073
43074
43075
43076
43077
43078
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*ELSET,ELSET=Nut
27226
27227
27228
27229
27230
27231
27232
27233
27234
27235
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*ELSET,ELSET=Washer_1
1936
1937
1938
1939
1940
1941
1942
1943
1944
1945
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*SURFACE,NAME=bonded_contact_faces
60519,S1
73176,S3
74212,S4
78459,S3
73601,S4
87753,S3
101633,S1
108340,S1
60269,S4
101544,S1
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*SURFACE,NAME=bonded_contact_faces(9)
4149,S3
10702,S1
7351,S2
36240,S2
15043,S2
53044,S1
29928,S1
54682,S4
53454,S1
10663,S1
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*SURFACE,NAME=bonded_contact_faces(4)
933,S2
57364,S1
40697,S1
40787,S2
57981,S2
335,S2
524,S2
57046,S2
47537,S4
1061,S1
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*SURFACE,NAME=bonded_contact_faces(3)
18704,S1
53566,S1
25063,S2
18354,S3
53568,S4
51292,S1
3689,S1
20980,S2
38933,S3
3704,S1
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*SURFACE,NAME=bonded_contact_faces(5)
19620,S3
20517,S2
20337,S3
19827,S1
56206,S4
20488,S2
56100,S1
17789,S2
20672,S3
55792,S4
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*SURFACE,NAME=bonded_contact_faces(6)
43724,S3
43492,S4
44610,S4
45220,S1
43686,S4
44911,S4
45147,S4
47116,S2
43637,S3
44450,S4
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*SURFACE,NAME=bonded_contact_faces(7)
31168,S3
28328,S2
31781,S2
30563,S3
28041,S3
27346,S4
30562,S4
30191,S3
32021,S3
31787,S2
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*SURFACE,NAME=bonded_contact_faces(8)
56586,S1
55333,S2
20628,S2
17656,S2
17712,S4
17831,S3
20594,S3
56349,S4
56348,S4
20599,S3
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*SURFACE,NAME=contact_faces(2)
47307,S4
45268,S4
43554,S3
43546,S2
43274,S3
47453,S2
45052,S1
45888,S3
43992,S1
45594,S2
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*SURFACE,NAME=contact_faces
57937,S4
58542,S3
41820,S3
58912,S1
42188,S2
41856,S2
58760,S2
58976,S4
190,S3
42285,S4
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*SURFACE,NAME=contact_faces(4)
72803,S3
78361,S2
76351,S2
100740,S2
65801,S2
89917,S1
64045,S3
64044,S4
94524,S4
107574,S3
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*SURFACE,NAME=contact_faces(3)
32006,S4
28515,S3
28044,S1
27848,S1
31074,S2
31004,S2
31734,S1
28103,S2
27390,S1
30369,S2
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*MATERIAL,NAME=Solid_AISI_E4340_H_Steel(4)
*ELASTIC,TYPE=ISOTROPIC
212000000000,0.3
*DENSITY
7850
*MATERIAL,NAME=Solid_AISI_E4340_H_Steel
*ELASTIC,TYPE=ISOTROPIC
212000000000,0.3
*DENSITY
7850
*MATERIAL,NAME=Solid_Aluminum
*ELASTIC,TYPE=ISOTROPIC
71000000000,0.33
*DENSITY
2770
*MATERIAL,NAME=Solid_Stainless_Steel
*ELASTIC,TYPE=ISOTROPIC
197000000000,0.43
*DENSITY
7750
*PLASTIC,HARDENING=ISOTROPIC
862000000,0
151362000000,1000
*MATERIAL,NAME=Solid_AISI_E4340_H_Steel(2)
*ELASTIC,TYPE=ISOTROPIC
212000000000,0.3
*DENSITY
7850
*MATERIAL,NAME=Solid_AISI_E4340_H_Steel(3)
*ELASTIC,TYPE=ISOTROPIC
212000000000,0.3
*DENSITY
7850
*SOLID SECTION,ELSET=Washer_2,MATERIAL=Solid_AISI_E4340_H_Steel(4)
*SOLID SECTION,ELSET=Bolt,MATERIAL=Solid_AISI_E4340_H_Steel
*SOLID SECTION,ELSET=Material_1,MATERIAL=Solid_Aluminum
*SOLID SECTION,ELSET=Material_2,MATERIAL=Solid_Stainless_Steel
*SOLID SECTION,ELSET=Nut,MATERIAL=Solid_AISI_E4340_H_Steel(2)
*SOLID SECTION,ELSET=Washer_1,MATERIAL=Solid_AISI_E4340_H_Steel(3)
*BOUNDARY
68820,1,,0
68820,2,,0
68820,3,,0
68821,1,,0
68821,2,,0
68821,3,,0
68822,1,,0
68822,2,,0
68822,3,,0
68823,1,,0
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*CONTACT PAIR,INTERACTION=SI_1,TYPE=SURFACE TO SURFACE,ADJUST=1.218605760695
bonded_contact_faces,bonded_contact_faces(9)
*SURFACE INTERACTION,NAME=SI_1
*SURFACE BEHAVIOR,PRESSURE-OVERCLOSURE=TIED
1.2E+13
*FRICTION
1,1.2E+13
*CONTACT PAIR,INTERACTION=SI_2,TYPE=SURFACE TO SURFACE,ADJUST=1.218605760695
bonded_contact_faces(4),bonded_contact_faces(3)
*SURFACE INTERACTION,NAME=SI_2
*SURFACE BEHAVIOR,PRESSURE-OVERCLOSURE=TIED
1.2E+13
*FRICTION
1,1.2E+13
*CONTACT PAIR,INTERACTION=SI_3,TYPE=SURFACE TO SURFACE,ADJUST=1.218605760695
bonded_contact_faces(5),bonded_contact_faces(6)
*SURFACE INTERACTION,NAME=SI_3
*SURFACE BEHAVIOR,PRESSURE-OVERCLOSURE=TIED
1.2E+13
*FRICTION
1,1.2E+13
*CONTACT PAIR,INTERACTION=SI_4,TYPE=SURFACE TO SURFACE,ADJUST=1.218605760695
bonded_contact_faces(7),bonded_contact_faces(8)
*SURFACE INTERACTION,NAME=SI_4
*SURFACE BEHAVIOR,PRESSURE-OVERCLOSURE=TIED
1.2E+13
*FRICTION
1,1.2E+13
*CONTACT PAIR,INTERACTION=SI_5,TYPE=SURFACE TO SURFACE
contact_faces(2),contact_faces
*SURFACE INTERACTION,NAME=SI_5
*SURFACE BEHAVIOR,PRESSURE-OVERCLOSURE=LINEAR
1.2E+13
*FRICTION
0.61,1.2E+13
*CONTACT PAIR,INTERACTION=SI_6,TYPE=SURFACE TO SURFACE
contact_faces(4),contact_faces(3)
*SURFACE INTERACTION,NAME=SI_6
*SURFACE BEHAVIOR,PRESSURE-OVERCLOSURE=LINEAR
1.2E+13
*FRICTION
0.8,1.2E+13
*STEP,NLGEOM=YES,INC=100
*STATIC,SOLVER=PARDISO
1,1,0,0
*CLOAD
104553,3,-0.03193562584886
104547,3,-0.03155169670934
104546,3,-0.04357980109032
111936,3,-52.30300660694
111935,3,-50.00057651949
111937,3,-52.67215346254
104551,3,-0.04271767636177
112646,3,-49.29498636589
112645,3,-53.07371632481
104539,3,-0.0393557780264
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*NODE FILE,GLOBAL=YES
U,RF
*EL FILE
S,NOE
*END STEP
